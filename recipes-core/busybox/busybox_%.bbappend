#SRC_URI_append = "file://bbextra.cfg"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
